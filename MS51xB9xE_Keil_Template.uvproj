# Keil uVision project MS51xB9xE_Keil_Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: MS51xB9xE_Keil_Template +hex
  AfterMake: .\FwLib\Startup\EXE\hex2bin.exe  .\Objects\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\FwLib\StdDriver\inc;.\FwLib\Device\Include
  group Startup
    ./FwLib/Startup/Keil/: STARTUP.A51
  group User
    ./User/: main.c
  group StdLib
    ./FwLib/StdDriver/src/: uart.c sys.c common.c delay.c
